# IAR project km4_application.ewp, settings and files
configuration is (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32
  ICCARM.IExtraOptions: --no_path_in_file_macros; --cmse
  ICCARM.CCIncludePath2: ..\..\component\os\; ..\..\component\os\freertos; ..\..\component\os\freertos\freertos_v10.2.0\Source\include\; ..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\non_secure; ..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\secure; ..\..\component\soc\realtek\amebad\cmsis\; ..\..\component\soc\realtek\amebad\cmsis\device; ..\..\component\soc\realtek\amebad\fwlib\include; ..\..\component\soc\realtek\amebad\fwlib\rom_map_hp; ..\..\component\soc\realtek\amebad\app\monitor\include; ..\..\component\soc\realtek\amebad\app\xmodem; ..\..\component\soc\realtek\amebad\swlib\include; ..\..\component\soc\realtek\amebad\swlib\string; ..\..\component\soc\realtek\amebad\misc; ..\..\component\soc\realtek\amebad\swlib\os_dep\include\; ..\..\component\soc\realtek\amebad\swlib\os_dep\..\; ..\..\component\soc\realtek\amebad\swlib\string; ..\inc\inc_hp; ..\..\component\common\api; ..\..\component\common\api\platform; ..\..\component\common\api\wifi; ..\..\component\common\api\network; ..\..\component\common\api\network\include; ..\..\component\common\audio; ..\..\component\common\test; ..\..\component\common\example; ..\..\component\common\utilities; ..\..\component\common\drivers\si; ..\..\component\common\audio\haac; ..\..\component\common\audio\hmp3; ..\..\component\common\audio\fdk-aac; ..\..\component\common\audio\libav; ..\..\component\common\audio\fdk-aac\libSYS\include; ..\..\component\common\drivers\wlan\realtek\include; ..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\component\common\drivers\wlan\realtek\src\hal\phydm; ..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d; ..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d\little_driver\include; ..\..\component\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\..\component\common\network; ..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\component\common\network\lwip\lwip_v2.0.2\src\include\netif; ..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\component\common\api; ..\..\component\common\api\at_cmd; ..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\component\os\os_dep\include\; ..\..\component\common\drivers\inic\rtl8721d; ..\..\component\common\network\ssl\polarssl-1.3.8\include; ..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\component\common\network\ssl\mbedtls_ram_map\rom; ..\..\component\common\mbed\targets\hal\rtl8721d\; ..\..\component\common\mbed\targets\hal\rtl8721d\include; ..\..\component\common\mbed\api; ..\..\component\common\mbed\hal; ..\..\component\common\mbed\hal_ext; ..\..\component\common\application\baidu\libduer-device\external\mbedtls-port; ..\..\component\common\application\apple\WACServer\External\Curve25519; ..\..\component\common\application\apple\WACServer\External\GladmanAES; ..\..\component\common\application\apple\homekit\crypto\chacha; ..\..\component\common\application\apple\homekit\crypto\poly1305; ..\..\component\common\application\apple\homekit\crypto\ed25519; ..\..\component\common\application\apple\homekit\crypto\ed25519\core; ..\..\component\common\application\apple\homekit\crypto\sha512; ..\..\component\common\file_system\fatfs\r0.10c\include; ..\..\component\common\file_system\fatfs; ..\..\component\common\file_system\ftl; ..\..\component\common\application\baidu\libduer-device\framework\core; ..\..\component\common\application\baidu\libduer-device\framework\include; ..\..\component\common\application\baidu\duerapp\include; $TOOLKIT_DIR$\inc\c; ..\..\component\common\network\coap\include; ..\..\component\common\drivers\sdio\realtek\sdio_host\inc; ..\..\component\common\drivers\wlan\realtek\src\core\option; ..\..\component\common\api\wifi\rtw_wpa_supplicant\src\crypto; ..\..\component\common\application\amazon\amazon-freertos\lib\include\private; ..\src\src_hp; ..\..\component\common\drivers\ir\protocol; ..\..\component\common\ui\emwin\emWinLibrary\include; ..\..\component\common\ui\emwin\Sample\rtl8721d\Config; ..\..\component\common\ui\emwin\Sample\rtl8721d\hal; ..\..\component\common\ui\emwin\Third_Party\truetype; ..\..\component\common\drivers\ir\protocol; ..\..\component\common\network\libcoap\include; ..\..\component\common\bluetooth\realtek\sdk; ..\..\component\common\bluetooth\realtek\sdk\board\amebad\lib; ..\..\component\common\bluetooth\realtek\sdk\board\amebad\src; ..\..\component\common\bluetooth\realtek\sdk\board\amebad\src\hci; ..\..\component\common\bluetooth\realtek\sdk\board\amebad\src\vendor_cmd; ..\..\component\common\bluetooth\realtek\sdk\board\common\inc; ..\..\component\common\bluetooth\realtek\sdk\example\ble_central; ..\..\component\common\bluetooth\realtek\sdk\example\ble_peripheral; ..\..\component\common\bluetooth\realtek\sdk\example\ble_scatternet; ..\..\component\common\bluetooth\realtek\sdk\example\bt_airsync_config; ..\..\component\common\bluetooth\realtek\sdk\example\bt_beacon; ..\..\component\common\bluetooth\realtek\sdk\example\bt_breeze; ..\..\component\common\bluetooth\realtek\sdk\example\bt_config; ..\..\component\common\bluetooth\realtek\sdk\example\bt_tag_scanner; ..\..\component\common\bluetooth\realtek\sdk\example\bt_ancs; ..\..\component\common\bluetooth\realtek\sdk\example\bt_distance_detector; ..\..\component\common\bluetooth\realtek\sdk\inc; ..\..\component\common\bluetooth\realtek\sdk\inc\app; ..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\gap; ..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile; ..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\client; ..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\component\common\bluetooth\realtek\sdk\inc\os; ..\..\component\common\bluetooth\realtek\sdk\inc\platform; ..\..\component\common\bluetooth\realtek\sdk\inc\stack; ..\..\component\common\bluetooth\realtek\sdk\src\mcu\module\data_uart_cmd; ..\..\component\common\application\airsync\1.0.4; ..\..\component\common\application\breeze\api; ..\..\component\common\application\breeze\core\include; ..\..\component\common\application\breeze\include; ..\..\component\common\application\breeze\ref-impl; ..\..\component\common\network\ssl\mbedtls-2.4.0\include\mbedtls; ..\..\component\common\file_system\dct; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\cmd; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\common; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\gap; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc\amebad; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model\realtek; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\platform; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\profile; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\provisioner; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\device; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_device_rtk_demo; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo\inc; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\device; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\provisioner; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_multiple_profile\device_multiple_profile; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_multiple_profile\provisioner_multiple_profile; ..\..\component\common\media\mmfv2; ..\..\component\common\media\rtp_codec
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\non_secure; ..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\secure; ..\inc\inc_hp
  OBJCOPY.OOCOutputFile: km4_application.srec
  prebuild: CSCRIPT  "..\..\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721d_prebuild.vbs" "$PROJ_DIR$" "..\inc\inc_hp"
  postbuild: CSCRIPT  "..\..\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721dhp_postbuild_img2.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$TOOLKIT_DIR$" "normal"
  ILINK.IlinkOutputFile: km4_application.axf
  ILINK.IlinkIcfFile: rtl8721dhp_image2_is.icf
  ILINK.IlinkExtraOptions: --redirect aesccmp_construct_mic_iv=aesccmp_construct_mic_iv_ram; --redirect aesccmp_construct_mic_header1=aesccmp_construct_mic_header1_ram; --redirect aesccmp_construct_ctr_preload=aesccmp_construct_ctr_preload_ram; --redirect rom_psk_CalcGTK=ram_patch_rom_psk_CalcGTK; --redirect rom_psk_CalcPTK=ram_patch_rom_psk_CalcPTK; --redirect aes_80211_encrypt=ram_patch_aes_80211_encrypt; --redirect aes_80211_decrypt=ram_patch_aes_80211_decrypt
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration is (mp) (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32; CONFIG_MP_INCLUDED; CONFIG_BT_MP
  ICCARM.CCIncludePath2: ..\..\component\os\; ..\..\component\os\freertos; ..\..\component\os\freertos\freertos_v10.2.0\Source\include\; ..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\non_secure; ..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\secure; ..\..\component\soc\realtek\amebad\cmsis\; ..\..\component\soc\realtek\amebad\cmsis\device; ..\..\component\soc\realtek\amebad\fwlib\include; ..\..\component\soc\realtek\amebad\fwlib\rom_map_hp; ..\..\component\soc\realtek\amebad\app\monitor\include; ..\..\component\soc\realtek\amebad\app\xmodem; ..\..\component\soc\realtek\amebad\swlib\include; ..\..\component\soc\realtek\amebad\swlib\string; ..\..\component\soc\realtek\amebad\misc; ..\..\component\soc\realtek\amebad\swlib\os_dep\include\; ..\..\component\soc\realtek\amebad\swlib\os_dep\..\; ..\..\component\soc\realtek\amebad\swlib\string; ..\inc\inc_hp; ..\..\component\common\api; ..\..\component\common\api\platform; ..\..\component\common\api\wifi; ..\..\component\common\api\network; ..\..\component\common\api\network\include; ..\..\component\common\audio; ..\..\component\common\test; ..\..\component\common\example; ..\..\component\common\utilities; ..\..\component\common\drivers\si; ..\..\component\common\audio\haac; ..\..\component\common\audio\hmp3; ..\..\component\common\audio\fdk-aac; ..\..\component\common\audio\libav; ..\..\component\common\audio\fdk-aac\libSYS\include; ..\..\component\common\drivers\wlan\realtek\include; ..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\component\common\drivers\wlan\realtek\src\hal\phydm; ..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d; ..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d\little_driver\include; ..\..\component\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\..\component\common\network; ..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\component\common\network\lwip\lwip_v2.0.2\src\include\netif; ..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\component\common\api; ..\..\component\common\api\at_cmd; ..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\component\os\os_dep\include\; ..\..\component\common\drivers\inic\rtl8721d; ..\..\component\common\network\ssl\polarssl-1.3.8\include; ..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\component\common\network\ssl\mbedtls_ram_map\rom; ..\..\component\common\mbed\targets\hal\rtl8721d\; ..\..\component\common\mbed\targets\hal\rtl8721d\include; ..\..\component\common\mbed\api; ..\..\component\common\mbed\hal; ..\..\component\common\mbed\hal_ext; ..\..\component\common\application\baidu\libduer-device\external\mbedtls-port; ..\..\component\common\application\apple\WACServer\External\Curve25519; ..\..\component\common\application\apple\WACServer\External\GladmanAES; ..\..\component\common\application\apple\homekit\crypto\chacha; ..\..\component\common\application\apple\homekit\crypto\poly1305; ..\..\component\common\application\apple\homekit\crypto\ed25519; ..\..\component\common\application\apple\homekit\crypto\ed25519\core; ..\..\component\common\application\apple\homekit\crypto\sha512; ..\..\component\common\file_system\fatfs\r0.10c\include; ..\..\component\common\file_system\fatfs; ..\..\component\common\file_system\ftl; ..\..\component\common\application\baidu\libduer-device\framework\core; ..\..\component\common\application\baidu\libduer-device\framework\include; ..\..\component\common\application\baidu\duerapp\include; $TOOLKIT_DIR$\inc\c; ..\..\component\common\network\coap\include; ..\..\component\common\drivers\sdio\realtek\sdio_host\inc; ..\..\component\common\drivers\wlan\realtek\src\core\option; ..\..\component\common\api\wifi\rtw_wpa_supplicant\src\crypto; ..\..\component\common\application\amazon\amazon-freertos\lib\include\private; ..\..\component\common\ui\emwin\emWinLibrary\include; ..\..\component\common\ui\emwin\Sample\rtl8721d\Config; ..\..\component\common\ui\emwin\Sample\rtl8721d\hal; ..\..\component\common\ui\emwin\Third_Party\truetype; ..\..\component\common\network\libcoap\include; ..\..\component\common\bluetooth\realtek\sdk; ..\..\component\common\bluetooth\realtek\sdk\board\amebad\lib; ..\..\component\common\bluetooth\realtek\sdk\board\amebad\src; ..\..\component\common\bluetooth\realtek\sdk\board\amebad\src\hci; ..\..\component\common\bluetooth\realtek\sdk\board\amebad\src\vendor_cmd; ..\..\component\common\bluetooth\realtek\sdk\board\common\inc; ..\..\component\common\bluetooth\realtek\sdk\example\ble_central; ..\..\component\common\bluetooth\realtek\sdk\example\ble_peripheral; ..\..\component\common\bluetooth\realtek\sdk\example\ble_scatternet; ..\..\component\common\bluetooth\realtek\sdk\example\bt_airsync_config; ..\..\component\common\bluetooth\realtek\sdk\example\bt_beacon; ..\..\component\common\bluetooth\realtek\sdk\example\bt_breeze; ..\..\component\common\bluetooth\realtek\sdk\example\bt_config; ..\..\component\common\bluetooth\realtek\sdk\inc; ..\..\component\common\bluetooth\realtek\sdk\inc\app; ..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\gap; ..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile; ..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\client; ..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\component\common\bluetooth\realtek\sdk\inc\os; ..\..\component\common\bluetooth\realtek\sdk\inc\platform; ..\..\component\common\bluetooth\realtek\sdk\inc\stack; ..\..\component\common\bluetooth\realtek\sdk\src\mcu\module\data_uart_cmd; ..\..\component\common\application\airsync\1.0.4; ..\..\component\common\application\breeze\api; ..\..\component\common\application\breeze\core\include; ..\..\component\common\application\breeze\include; ..\..\component\common\application\breeze\ref-impl; ..\..\component\common\network\ssl\mbedtls-2.4.0\include\mbedtls; ..\..\component\common\file_system\dct; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\device; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\provisioner; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\device; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\cmd; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\common; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\gap; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc\amebaz2; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model\realtek; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\platform; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\profile; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\provisioner; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_device_rtk_demo; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_multiple_profile\device_multiple_profile; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_multiple_profile\provisioner_multiple_profile; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo; ..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo\inc; ..\..\component\common\media\mmfv2; ..\..\component\common\media\rtp_codec
  AARM.ADefines: as above
  postbuild: CSCRIPT  "..\..\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721dhp_postbuild_img2.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$TOOLKIT_DIR$" "mp"
configuration tz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32; CONFIG_TRUSTZONE_EN=1; CONFIG_BUILD_NONSECURE=1
  ICCARM.CCIncludePath2: as above
  AARM.ADefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32; CONFIG_TRUSTZONE_EN=1
  ILINK.IlinkIcfFile: rtl8721dhp_image2_tz.icf
configuration tz (mp) (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32; CONFIG_TRUSTZONE_EN=1; CONFIG_BUILD_NONSECURE=1; CONFIG_MP_INCLUDED; CONFIG_BT_MP
  ICCARM.CCIncludePath2: as above
  AARM.ADefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32; CONFIG_TRUSTZONE_EN=1; CONFIG_MP_INCLUDED; CONFIG_BT_MP
  postbuild: as above
  ILINK.IlinkIcfFile: rtl8721dhp_image2_tz.icf
  group @SRAM/network/lwip/port
    ../../component/common/network/lwip/lwip_v2.0.2/port/realtek/freertos/: br_rpt_handle.c bridgeif.c bridgeif_fdb.c ethernetif.c sys_arch.c
    ../../component/common/drivers/wlan/realtek/src/osdep/: lwip_intf.c
  group @SRAM/network/lwip/src/api
    ../../component/common/network/lwip/lwip_v2.0.2/src/api/: api_lib.c api_msg.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group @SRAM/network/lwip/src/core
    ../../component/common/network/lwip/lwip_v2.0.2/src/core/: def.c inet_chksum.c ip.c mem.c memp.c netif.c pbuf.c raw.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../component/common/network/lwip/lwip_v2.0.2/src/core/ipv4/: etharp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../component/common/network/lwip/lwip_v2.0.2/src/core/ipv6/: ethip6.c ip6.c ip6_addr.c ip6_frag.c
  group @SRAM/network/lwip/src/netif
    ../../component/common/network/lwip/lwip_v2.0.2/src/netif/: ethernet.c
  group @SRAM/os/freertos
    ../../component/os/freertos/: cmsis_os.c freertos_backtrace_ext.c freertos_cb.c freertos_heap5_config.c freertos_service.c
  group @SRAM/os/freertos/source
    ../../component/os/freertos/freertos_v10.2.0/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../component/os/freertos/freertos_v10.2.0/Source/portable/MemMang/: heap_5.c
  group @SRAM/os/freertos/source/portable
    ../../component/os/freertos/freertos_v10.2.0/Source/portable/IAR/RTL8721D_HP/non_secure/: port.c portasm.s
  group @SRAM/os/os_dep
    ../../component/os/os_dep/: device_lock.c osdep_service.c psram_reserve.c
  group fwlib
    ../../component/soc/realtek/amebad/fwlib/ram_common/: rtl8721d_adc.c rtl8721d_bor.c rtl8721d_captouch.c rtl8721d_comparator.c rtl8721d_flash_ram.c rtl8721d_gdma_memcpy.c rtl8721d_i2c.c rtl8721d_ipc_api.c rtl8721d_ir.c rtl8721d_keyscan.c rtl8721d_pll.c rtl8721d_ram_libc.c rtl8721d_rtc.c rtl8721d_sgpio.c rtl8721d_tim.c rtl8721d_uart.c rtl8721d_wdg.c
    ../../component/soc/realtek/amebad/fwlib/crypto/: rtl8721dhp_aes_ram.c rtl8721dhp_chacha_poly1305.c rtl8721dhp_crypto_ram.c rtl8721dhp_des_ram.c rtl8721dhp_md5.c rtl8721dhp_sha.c
    ../../component/soc/realtek/amebad/fwlib/ram_hp/: rtl8721dhp_app_start.c rtl8721dhp_audio.c rtl8721dhp_clk.c rtl8721dhp_cpft.c rtl8721dhp_i2s.c rtl8721dhp_lcdc.c rtl8721dhp_ota_ram.c rtl8721dhp_sd.c rtl8721dhp_sdio.c rtl8721dhp_sdio_host.c rtl8721dhp_simulation.c rtl8721dhp_ssi.c rtl8721dhp_startup.c rtl8721dhp_system.c rtl8721dhp_usi_i2c.c rtl8721dhp_usi_ssi.c rtl8721dhp_usi_uart.c
  group fwlib/usrcfg
    ../../component/soc/realtek/amebad/fwlib/usrcfg/: rtl8721d_ipccfg.c rtl8721d_wificfg.c rtl8721dhp_intfcfg.c rtl8721dlp_intfcfg.c
  group lib
    ../../component/common/bluetooth/realtek/sdk/board/amebad/lib/: btgap.a
    ../../component/soc/realtek/amebad/misc/bsp/lib/common/IAR/: cmse_implib.a cmse_implib_mp.a lib_ac3.a lib_amr.a lib_coap.a lib_dct.a lib_eap.a lib_ekho.a lib_gsm610.a lib_haac.a lib_hmp3.a lib_httpc.a lib_httpd.a lib_libogg.a lib_mdns.a lib_mmfv2.a lib_mp3.a lib_opus.a lib_opusenc.a lib_opusfile.a lib_pmc_hp.a lib_rtp_codec.a lib_rtsp.a lib_tftp.a lib_usbd.a lib_usbh.a lib_v4l2.a lib_websocket.a lib_wlan.a lib_wlan_mp.a lib_wps.a
  group mbed
    ../../component/common/mbed/targets/hal/rtl8721d/: analogin_api.c dma_api.c efuse_api.c flash_api.c gpio_api.c gpio_irq_api.c i2c_api.c i2s_api.c pinmap.c pinmap_common.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spdio_api.c spi_api.c sys_api.c timer_api.c us_ticker.c us_ticker_api.c wait_api.c wdt_api.c
  group user
    ../src/src_hp/: main.c
  group wifi/api
    ../../component/common/api/at_cmd/: atcmd_bt.c atcmd_lwip.c atcmd_mp.c atcmd_mp_ext0.c atcmd_mp_ext1.c atcmd_mp_ext2.c atcmd_sys.c atcmd_wifi.c log_service.c
    ../../component/common/api/: lwip_netconf.c wifi_interactive_mode.c
    ../../component/common/api/network/src/: ping_test.c ttcp.c wlan_network.c
    ../../component/common/api/wifi/rtw_wpa_supplicant/src/crypto/: tls_polarssl.c
    ../../component/common/api/wifi/: wifi_conf.c wifi_ind.c wifi_promisc.c wifi_simple_config.c wifi_util.c
    ../../component/common/api/wifi/rtw_wpa_supplicant/wpa_supplicant/: wifi_eap_config.c wifi_p2p_config.c wifi_wps_config.c
  group wifi/network
    ../../component/common/network/dhcp/: dhcps.c
    ../../component/common/network/sntp/: sntp.c
  group wifi/network/lwip/api
    ../../component/common/network/lwip/lwip_v2.0.2/src/api/: err.c
  group wifi/network/lwip/core
    ../../component/common/network/lwip/lwip_v2.0.2/src/core/ipv4/: autoip.c dhcp.c icmp.c
    ../../component/common/network/lwip/lwip_v2.0.2/src/core/ipv6/: dhcp6.c icmp6.c inet6.c mld6.c nd6.c
    ../../component/common/network/lwip/lwip_v2.0.2/src/core/: dns.c init.c stats.c sys.c
  group wifi/network/mDNS
    ../../component/common/network/mDNS/: mDNSPlatform.c
  group wifi/network/ssl/library
    ../../component/common/network/ssl/mbedtls-2.4.0/library/: aesni.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c debug.c ecp_ram.c entropy.c entropy_poll.c error.c gcm.c havege.c memory_buffer_alloc.c net_sockets.c padlock.c pkcs11.c pkcs12.c pkcs5.c pkparse.c platform.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c
    ../../component/common/network/ssl/mbedtls-2.4.0/: mbedtls_rom_test.c
    ../../component/common/network/ssl/ssl_ram_map/: ssl_ram_map.c
  group wifi/network/ssl/ssl_wrapper
    ../../component/common/network/ssl/ssl_wrapper/: ssl_wrapper.c
